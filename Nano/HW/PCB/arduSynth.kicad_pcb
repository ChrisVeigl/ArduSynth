# Repository ChrisVeigl/ArduSynth

File README.md:

# ArduSynth
HW/SW for low-cost Arduino-based audio synthesizers, using the Mozzi Library.
Currently, two designs are available: one for the Arduino Nano and one for the TeensyLC microcontroller. The TeensyLC version is recommended and will be updated in the future - it offers more features like Midi control via the Teensy's usbMidi functions.
The KICad projects (Schematics, PCB) are available in the respective HW folders, partnumbers @ digikey / Aliexpress are provided.

## About the demo Synth Sketches

Synthesizer sketches can be added / modified on demand. Currently there are two demo synth designs available, based upon:

* the "K'iin" Synthesizer by Taylan Cihan, see: http://digital.music.cornell.edu/taylancihan/kiin.html
 
* the "Thankyou Drone Synth" by Daniel Sinderson, see:
   https://create.arduino.cc/projecthub/scraptured/phasemod-drone-synth-w-arduino-nano-mozzi-7ab2ff 

## SW-Build instructions and Dependencies

* for compiling the software, the Mozzi-Library must be installed / copied to the Arduino libraries folder, see:
https://github.com/sensorium/Mozzi 

For the TeensyLC version, follwing alternative/additional libraries are used:
* currently this branch of the Mozzi library is needed for TeensyLC support: https://github.com/tomcombriat/Mozzi/tree/Teensy4X
* the Adafruit library for the SSD1306 OLed-Display is used: https://github.com/adafruit/Adafruit_SSD1306 
Please note that a modified version of this library is delivered in the src folder - the display method was adapted in order to call audioHook() - which prevents distorted audio during display updates.
* furthermore, the Adafruit GFX library https://github.com/adafruit/Adafruit-GFX-Library and the Adafruit BUI-IO library https://github.com/adafruit/Adafruit_BusIO are needed - they can be installed from the Arduinos Library manager.
* in order to use the correct I2C interface of the TeensyLC, the Wire1 interface must be enabled either by adding "-DWIRE_IMPLEMENT_WIRE1" to the teensyLC.build.flags.defs in the file Arduino\hardware\teensy\avr\boards.txt file or by uncommenting line 43 in file Arduino\hardware\teensy\avr\libraries\Wire\WireKinetis.h

## KiCad design Nano/HW/PCB/arduSynth.kicad_pcb

Board: 2 copper layers, 100.3 x 100.3 mm, 36 parts (0 on the bottom side), 35 nets.

Parts:
A1: Arduino_Nano_v3.x; Arduino_Nano
C1: 4.7n; C_Rect_L4.6mm_W2.0mm_P2.50mm_MKS02_FKP02
D1, D2, D3: LED; LED_D5.0mm
J1: AudioJack3_Ground; FC68125
J2, J3, J4, J5, J6, J7, J8, J9, J10: Conn_01x03_Male; PinHeader_1x03_P2.54mm_Vertical
J11, J14: Screw_Terminal_01x02; TerminalBlock_bornier-2_P5.08mm
J12, J13: Conn_01x02_Male; PinHeader_1x02_P2.54mm_Vertical
R1, R2, R3: 470; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
R4: 3.9K; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
RV1, RV2, RV3, RV4, RV5, RV6, RV7, RV8, RV9: 100K; Potentiometer_Alps_RK09K_Single_Vertical_modified
SW1, SW2, SW3, SW4: SW_Push; SW_PUSH-12mm_Wuerth-430476085716

Connections:
+5V: A1.27, RV1.3, RV2.3, RV3.3, RV4.3, RV5.3, RV6.3, RV7.3, RV8.3
GND: A1.4, A1.29, C1.2, D1.1, D2.1, D3.1, J1.G, J11.2, J14.2, RV1.1, RV2.1, RV3.1, RV4.1, RV5.1, RV6.1, RV7.1, RV8.1, RV9.3, SW1.1, SW2.1, SW3.1, SW4.1
unnamed: A1.6, SW1.2
unnamed: A1.7, SW2.2
unnamed: A1.8, SW3.2
unnamed: A1.9, R1.2
unnamed: A1.10, R2.2
unnamed: A1.11, R3.2
unnamed: A1.12, R4.2
unnamed: A1.14, SW4.2
unnamed: A1.19, J2.1, J2.2
unnamed: A1.20, J3.1, J3.2
unnamed: A1.21, J4.1, J4.2
unnamed: A1.22, J5.1, J5.2
unnamed: A1.23, J6.1, J6.2
unnamed: A1.24, J7.1, J7.2
unnamed: A1.25, J8.1, J8.2
unnamed: A1.26, J9.1, J9.2
unnamed: A1.30, J14.1
unnamed: C1.1, R4.1, RV9.1
unnamed: D1.2, R1.1
unnamed: D2.2, R2.1
unnamed: D3.2, R3.1
unnamed: J1.R, J13.1
unnamed: J1.T, J12.2
unnamed: J2.3, RV1.2
unnamed: J3.3, RV2.2
unnamed: J4.3, RV3.2
unnamed: J5.3, RV4.2
unnamed: J6.3, RV5.2
unnamed: J7.3, RV6.2
unnamed: J8.3, RV7.2
unnamed: J9.3, RV8.2
unnamed: J10.1, J10.2, J10.3, J11.1
unnamed: J12.1, J13.2, RV9.2

## KiCad design HW/PCB_TeensyLC/arduSynth.kicad_pcb

Parts:
C1: 4.7n; C_Rect_L4.6mm_W2.0mm_P2.50mm_MKS02_FKP02
D1, D2, D3: LED; LED_D5.0mm
H1, H2, H3: MountingHole; MountingHole_3.2mm_M3_Pad
J1: AudioJack3_Ground; FC68125
J2, J3, J4, J5, J6, J7, J8, J9, J10, J16, J17: Conn_01x03_Male; PinHeader_1x03_P2.54mm_Vertical
J11: Screw_Terminal_01x03; TerminalBlock_bornier-3_P5.08mm
J12, J13: Conn_01x02_Male; PinHeader_1x02_P2.54mm_Vertical
J15: display_connector_91601-304LF; 91601304LF; Mouser Part Number 649-91601-304LF
R1, R2, R3: 470; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
R4: 3.9K; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
R5, R6: 4.7K; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
RV1, RV2, RV3, RV4, RV5, RV6, RV7, RV8, RV9: 100K; Potentiometer_Alps_RK09K_Single_Vertical_modified
SW1, SW2, SW3, SW4: SW_Push; SW_PUSH-12mm_Wuerth-430476085716
U1: Teensy-LC; Teensy_LC

Connections:
+3V3: J11.1, J15.3, R5.1, R6.1, RV1.3, RV2.3, RV3.3, RV4.3, RV5.3, RV6.3, RV7.3, RV8.3, U1.16 (3.3V)
+5V: J16.1, J17.1, U1.33 (Vin)
AudioOut: R4.1, U1.19 (26_A12/DAC)
DataIn: J16.2, U1.2 (0_RX1_MOSI1_Touch)
DataOut: J17.2, U1.3 (1_TX1_MISO1_Touch)
GND: C1.2, D1.1 (K), D2.1 (K), D3.1 (K), J1.G, J11.3, J15.1, J16.3, J17.3, RV1.1, RV2.1, RV3.1, RV4.1, RV5.1, RV6.1, RV7.1, RV8.1, RV9.3, SW1.1, SW2.1, SW3.1, SW4.1, U1.1 (GND), U1.17 (GND)
unnamed: C1.1, R4.2, RV9.1
unnamed: D1.2 (A), R1.1
unnamed: D2.2 (A), R2.1
unnamed: D3.2 (A), R3.1
unnamed: J1.R, J13.1
unnamed: J1.T, J12.2
unnamed: J2.1, J2.2, U1.36 (24_A10)
unnamed: J2.3, RV1.2
unnamed: J3.1, J3.2, U1.28 (21_A7_MOSI1_RX1)
unnamed: J3.3, RV2.2
unnamed: J4.1, J4.2, U1.27 (20_A6_SCK1_PWM_TX3)
unnamed: J4.3, RV3.2
unnamed: J5.1, J5.2, U1.26 (19_A5_SCL0_Touch)
unnamed: J5.3, RV4.2
unnamed: J6.1, J6.2, U1.25 (18_A4_SDA0_Touch)
unnamed: J6.3, RV5.2
unnamed: J7.1, J7.2, U1.24 (17_A3_SDA0_PWM_Touch)
unnamed: J7.3, RV6.2
unnamed: J8.1, J8.2, U1.23 (16_A2_SCL0_PWM_Touch)
unnamed: J8.3, RV7.2
unnamed: J9.1, J9.2, U1.22 (15_A1_Touch)
unnamed: J9.3, RV8.2
unnamed: J10.1, J10.2, J10.3, J11.2
unnamed: J12.1, J13.2, RV9.2
unnamed: R1.2, U1.5 (3_RX1_PWM_Touch)
unnamed: R2.2, U1.6 (4_TX1_PWM_Touch)
unnamed: R3.2, U1.8 (6_RX3_CS1_PWM)
unnamed: SW1.2, U1.9 (7_RX3_MOSI0)
unnamed: SW2.2, U1.10 (8_TX3_MISO0)
unnamed: SW3.2, U1.11 (9_RX2_PWM)
unnamed: SW4.2, U1.12 (10_TX2_CS0_PWM)
SCL: J15.5, R5.2, U1.29 (22_A8_SCL1_PWM_Touch)
SDA: J15.7, R6.2, U1.30 (23_A9_SDA1_PWM_Touch)

Board: 2 copper layers, 99.8 x 99.8 mm, 43 parts (0 on the bottom side), 39 nets.

## Commit log

2021-09-24 added V1.0
2021-09-25 updated poti positions for PCB version 1.0
2021-09-25 added construction guide
2021-10-13 added teensy 3.x SW version
2021-10-16 improved Teensy LC sketch, added MIDI support
2021-10-17 added PCB version for TeensyLC
2021-10-24 updates for TeensyLC Version
2021-10-25 some final PCB updates for Teensynth V1.0
2021-10-26 udpated guide
2021-10-26 udpated ReadMe
2021-10-26 updated directory stucture to reflect both HW versions
2021-10-26 removed obsolete files to reflect both HW versions
2021-10-26 use traditional analogRead because of mozziAnalogRead problems on TeensyLC
2021-10-26 fixed abs problem
2021-10-30 added frequency table and correct carrier frequency for midi note on
2021-10-30 start envelope when note ons come in
2021-11-14 updates for TeensyLC and I2C-LCD
2021-11-14 improved code modularity
2021-11-16 added modified version of Adafruit SSD1306 library - preventing audio distortion during display updates
2022-01-09 added serial1 control link, removed bypass for all potis
2024-02-25 added neopixel lights
